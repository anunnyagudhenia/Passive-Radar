options:
  parameters:
    author: anunn
    generate_options: qt_gui
    id: crosscorrelation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: ''
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Cross-correlation block for passive radar.
          Input 0 : reference vector (complex)
          Input 1 : surveillance vector (complex)
          Output  : cross-correlation magnitude (float)
          """

          def __init__(self, N=4096):
              gr.basic_block.__init__(
                  self,
                  name="cross_corr_block",
                  in_sig=[(np.complex64, N), (np.complex64, N)],
                  out_sig=[(np.float32, N)],
              )
              self.N = N

          def general_work(self, input_items, output_items):
              ref = input_items[0][0]          # reference vector
              surv = input_items[1][0]         # surveillance vector
              out  = output_items[0][0]

              # Remove DC
              ref  = ref  - np.mean(ref)
              surv = surv - np.mean(surv)

              # FFT
              REF  = np.fft.fft(ref)
              SURV = np.fft.fft(surv)

              # Cross-correlation via frequency domain
              R = np.fft.ifft( SURV * np.conj(REF) )

              # Shift lag zero to center
              R = np.fft.fftshift(R)

              # Magnitude (real output)
              R_mag = np.abs(R)

              # Normalize
              R_mag = R_mag / (np.max(R_mag) + 1e-12)

              # Output
              out[:] = R_mag.astype(np.float32)

              # Consume 1 vector from each input
              self.consume(0, 1)
              self.consume(1, 1)

              return 1
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '4096'
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '100'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_1
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '100'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '1']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [soapy_rtlsdr_source_1, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
